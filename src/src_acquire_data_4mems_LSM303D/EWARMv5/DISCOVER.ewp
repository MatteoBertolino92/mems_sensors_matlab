# IAR project DISCOVER.ewp, settings and files
configuration DISCOVER (ARM, debug)
  General.OGChipSelectEditMenu: STM32F100xB ST STM32F100xB
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F10X_MD_VL
  ICCARM.CCIncludePath2: ..\inc\; ..\..\..\Libraries\STM32F10x_StdPeriph_Driver\inc\; ..\..\..\Utilities\; ..\..\..\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x; ..\LSM303D\
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: DISCOVER.hex
  ILINK.IlinkOutputFile: DISCOVER.out
  ILINK.IlinkIcfFile: stm32f100_flash.icf
  ILINK.IlinkProgramEntryLabel: Reset_Handler
  group CMSIS
    ../../../Libraries/CMSIS/CM3/CoreSupport/: core_cm3.c
    ../../../Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
  group DOC
    ../: readme.txt
  group EWARMv5
    ../../../Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/iar/: startup_stm32f10x_md_vl.s
  group StdPeriph_Driver
    ../../Demo/LSM303D/: lsm303d.c
    ../../../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_exti.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_tim.c stm32f10x_usart.c
  group stm32vldiscovery
    ../../../Utilities/: STM32vldiscovery.c
  group User
    ../src/: main.c stm32f10x_it.c
